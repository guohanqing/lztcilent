# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_HAL_DRIVER
  c misc: --locale=english
  c include: applications;.;drivers;fonts;.;imag;.;Libraries\CMSIS\Device\ST\STM32F1xx\Include;Libraries\CMSIS\Include;Libraries\STM32F1xx_HAL_Driver\Inc;lzt;.;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\usb\usbdevice;..\..\components\finsh;..\..\components\STemWin\Config;..\..\components\STemWin\inc;..\..\components\Lib;..\..\components\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c stm32f1xx_it.c drv_led.c drv_usart.c cvt.c drv_hwadc.c adc.c usart_wifi_esp8266.c drv_uart_finger.c drv_stm32f10x_spi.c drv_rtc.c drv_fsmc_lcd.c drv_lcd_ili9341.c drv_iic_touch_ft5216.c
    ./drivers/: drv_power.c
  group fonts
    fonts/: _song16.c _kai24.c
  group img
    imag/: welcome.c wifi.c zw100.c logo.c id.c fingerbitmap.c button_zw_pay.c button_zw_regedi.c
    ./imag/: sever_connected.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group STM32F1xx_HAL_Driver
    Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group lzt
    lzt/: app.c app_msgbox.c Fp_regist1.c Fp_regist2.c Fp_regist3.c keyboard.c payDLG.c payUDID.c user_phone_input.c owner_phone_input.c user_validation_input.c owner_validation_input.c mainDLG.c wifi_japDLG.c wifi_list.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/adc/: hwadc.c
    ../../components/drivers/misc/: pin.c
    drivers/: drv_gpio.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../components/drivers/usb/usbdevice/class/: mstorage.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group StemWin
    ../../components/STemWin/Config/: GUIConf.c GUIDRV.c GUI_TOUCH_Analog.c LCDConf_FlexColor.c
    ../../components/STemWin/OS/: GUI_X_OS.c
    ../../components/STemWin/: STemWinGUI_App.c
    ../../components/STemWin/Lib/: STemWin528_CM3_OS_Keil.lib
